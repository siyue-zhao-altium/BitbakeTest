# Build a simple, minimal root filesystem.
#
# This recipe is a simplified form of core-image-minimal.

SUMMARY = "A simple, minimal image"
LICENSE = "CLOSED"

IMAGE_INSTALL = ""

IMAGE_LINGUAS = ""